#include <stdio.h>
#include <stdlib.h>
#include "libs/biblioteca.h"

#define RED       "\033[31m"
#define YELLOW    "\033[33m"
#define BLUE      "\033[34m"
#define RESET     "\033[34m"

int main() {

    AbreLog();

    int c1,c2,x = 0;
    
    while(x == 0){

    system("clear");
    
    printf(" "RED"============================================================\n");
    printf(" |---ESCOLHA UMA DAS ALTERNATIVAS A BAIXO!------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |-----------DIGITE:"RESET"----------------------------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |"BLUE"----------1-Resolver equações circuito elétrico?----------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |----------2-Obter o valor de saída da expressão booleana?-|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |----------3-Se deseja sair--------------------------------|\n");
    printf(" |----------------------------------------------------------|\n");
    printf(" |-----------Qual opcão deseja fazer?---------------"RESET"--------|\n");
    printf(" ============================================================\n");
    scanf("%d", &c1);  
    getchar();
        
        switch(c1){
        
        case 1:
            system("clear");
            int cl = 1;

            while(cl == 1 )
            {
                system("clear");

                printf(" ============================================================\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |-------------"RED"INSERIR:"RESET"-------------------------------------|\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |"YELLOW"-------------1-Equacões duas malhas?----------------------|\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |-------------2-Equações três malhas?----------------------|\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |-------------3-Se deseja voltar---------------------------|\n");
                printf(" |----------------------------------------------------------|\n");
                printf(" |--------------Em qual formato ?---------------------------"RESET"|\n");
                printf(" ============================================================\n");

                scanf("%d",&c2);
                getchar();

                if (c2 == 1)
                {
                    system("clear");
                    equacao2();
                    printf(" ============================================================\n");
                    printf(" |"YELLOW"------------Digite enter para retornar--------------------"RESET"|\n");
                    printf(" ============================================================\n");
                   
                    getchar();
                    cl = 0;
                }
                if (c2 == 2)
                {
                    equacao3();
                    printf(" ============================================================\n");
                    printf(" |"YELLOW"------------Digite enter para retornar--------------------"RESET"|\n");
                    printf(" ============================================================\n");
                    cl = 0;
                    getchar();
                }
                if (c2 == 3)
                {
                    cl = 0;
                }                
                
                
                                
            }

        break;

        case 2:
            
            system("clear");
            algebra();
            getchar();

            printf("============================================================\n");
            printf("|"YELLOW"------------Digite enter para retornar--------------------"RESET"|\n");
            printf("============================================================\n");

            getchar();
         
        break;    
        
        case 3:
        printf(" ============================================================\n");
        printf(" |"RED"----------------------tchauzinho!-------------------------"RESET"|\n");
        printf(" ============================================================\n");
        printf("\n\n\n");
        return 0;
        x = 1;
        break;

        default:
                printf(" ============================================================\n");
                printf("|"YELLOW"----------------Digite um ou dois !---------------------"RESET"|\n");
                printf(" ============================================================\n");
                printf("Digite um ou dois !\n");
                break;
        }
        
    }
    
    
}